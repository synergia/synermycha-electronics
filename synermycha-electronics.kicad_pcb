# Repository synergia/synermycha-electronics

File README.md:

View this project on [CADLAB.io](https://cadlab.io/project/23388). 

# synermycha-electronics

## KiCad design synermycha-electronics.kicad_pcb

Notes on the sheet:
6V, 3V3

Parts:
C9, C10, C11, C12, C13, C19, C22: C_10u_16V_0603; 0603-cap; MPN GRM188C81C106MA73D
C14, C15, C16: C_100n_0402; 0402-cap; MPN GRM155R61H104KE14D
C17, C18, C20, C21: C_22u_0402; 0402-cap; MPN 04024W226MAT2A
J3, J4: B2B-PH-K-S_LF__SN_; PinHeader_1x2_P2mm_Drill1mm; MPN B2B-PH-K-S(LF)(SN)
L2, L3, L4: 74479276210C; L_0806_2016Metric; MPN 74479276210C
R6: R_64k9_0402; 0402-res; MPN RC0402FR-1364K9L
R7, R9, R13: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP
R8: R_47k_0402; 0402-res; MPN MCMR04X4702FTL
R10: R_30k9_0402; 0402-res; MPN ERJ-2RKF3092X
SW1: PCM12SMTR; MPN PCM13SMTR
TP1, TP2, TP3: TP_SMD_0_75MM; Testpoint_smd_0_75mm
U4, U5, U6: AP62250Z6-7; SOT-563; MPN AP62250Z6-7

Connections:
+3V3: C18.1, C21.1, L4.2, R10.2, TP2.1; also elsewhere on the board
/Power/3V3_BST: C16.1, U6.4 (BST)
/Power/3V3_FB: R10.1, R13.2, U6.6 (FB)
/Power/3V3_SW: C16.2, L4.1, U6.2 (SW)
/Power/PWR_ON: SW1.2, U4.5 (EN), U5.5 (EN), U6.5 (EN)
/Power/V_LED_BST: C15.1, U5.4 (BST)
/Power/V_LED_FB: R8.1, R9.2, U5.6 (FB)
/Power/V_LED_SW: C15.2, L3.1, U5.2 (SW)
/Power/V_MOT_BST: C14.1, U4.4 (BST)
/Power/V_MOT_FB: R6.1, R7.2, U4.6 (FB)
/Power/V_MOT_SW: C14.2, L2.1, U4.2 (SW)
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, J4.2, R7.1, R9.1, R13.1, SW1.3, SW1.S1 (SHIELD), SW1.S2 (SHIELD), SW1.S3 (SHIELD), SW1.S4 (SHIELD), U4.3 (GND), U5.3 (GND), U6.3 (GND); also elsewhere on the board
unnamed 102: J3.2, J4.1; also elsewhere on the board
V_LED_RGB: C17.1, C20.1, L3.2, R8.2, TP1.1
V_MOTOR: C19.1, C22.1, L2.2, R6.2, TP3.1

Notes on the sheet:
3.3V @2.5A
4.5V @2.5A
6V @2.5A

Parts:
C6, C28, C34, C37, C38, C39, C41, C42, C43, C46, C51, C52: C_220n_0402; 0402-cap; MPN CC0402KRX5R6BB224
C27, C45, C48, C50: C_10u_0402; 0402-cap; MPN CC0402MRX5R5BB106
C29, C32: C_12p_0402; 0402-cap; MPN CGA2B2C0G1H120J050BA
C30, C33: C_18p_0402; 0402-cap; MPN MC0402N180J500CT
C31, C40, C44, C47, C49: C_4u7_0402; 0402-cap; MPN GRM155R61A475MEAAD
C35, C36: C_10n_0402; 0402-cap; MPN 04025G103ZAT2A
FB1: MPZ1005S121CT000; 0402-res; MPN MPZ1005S121CT000
J1: TAG-10PIN; TC2050-IDC-NL_2x05_Vertical; MPN TC2050-IDC-NL
J2: USB4105-GF-A; GCT_USB4105-GF-A; MPN USB4105-GF-A
L1: SRP2512A-4R7M; SRP2512A-1R0M; MPN SRP2512A-1R0M
R11: R_100k_0402; 0402-res; MPN CRCW0402100KFKEDHP
R12: R_2M0_0402; 0402-res; MPN AC0402FR-072ML
TP13, TP14: TP_SMD_0_75MM; Testpoint_smd_0_75mm
U2, U10: W25Q64JVXGIM; WSON-8-1EP_4x4mm_P0.8mm_EP2.6x3mm; MPN W25Q64JVXGIM
U8: MIMXRT1061DVJ6B; NXP_MAPBGA-196_14x14_12.0x12.0mm; MPN MIMXRT1062DVJ6B
U9: MKL02Z32VFG4; VQFN-16-1EP_3x3mm; MPN MKL02Z32VFG4
Y1: ABM8G-24.000MHZ-18-D2Y-T; KX-7; MPN ABM8G-24.000MHZ-18-D2Y-T
Y2: ECS-_327-12_5-34B-TR; SMD-2_3.2x1.5mm; MPN ECS-.327-12.5-34B-TR

Connections:
+3V3: C6.1, C36.1, C39.1, C44.1, C48.1, C51.1, C52.1, FB1.1, J1.1 (VTref), U2.8 (VCC), U8.E6 (NVCC_EMP), U8.E9 (NVCC_GPIO), U8.F5 (NVCC_EMC), U8.F10 (NVCC_GPIO), U8.J6 (NVCC_SD0), U8.J10 (NVCC_GPIO), U8.K5 (NVCC_SD1), U8.M9 (VDD_SNVS_IN), U8.N14 (VDD_ADC), U8.P12 (VDD_HIGH_IN), U9.1 (VDD/VREFH), U10.8 (VCC); also elsewhere on the board
/uController/BOOT_MODE0: U8.F11 (GPIO_AD_B0_04), U9.4 (PTA4)
/uController/BOOT_MODE1: U8.G14 (GPIO_AD_B0_05)
/uController/BT_CFG9: U8.D10 (GPIO_B0_13), U9.12 (PTB4/IRQ_11)
/uController/FLASH.CLK: U8.L4 (GPIO_SD_B1_07), U10.6 (CLK)
/uController/FLASH.DATA0: U8.P3 (GPIO_SD_B1_08), U10.5 (DI/IO0)
/uController/FLASH.DATA1: U8.N4 (GPIO_SD_B1_09), U10.2 (DO/IO1)
/uController/FLASH.DATA2: U8.P4 (GPIO_SD_B1_10), U10.3 (~WP/IO2)
/uController/FLASH.DATA3: U8.P5 (GPIO_SD_B1_11), U10.7 (~HLD/~RST/IO3)
/uController/FLASH.~CS: U8.L3 (GPIO_SD_B1_06), U10.1 (~CS)
/uController/JTAG.TCK: J1.4 (SWDCLK/TCK), U8.F12 (GPIO_AD_B0_07), U9.8 (PTB0/IRQ_5)
/uController/JTAG.TDI: J1.8 (NC/TDI), U8.F14 (GPIO_AD_B0_09), U9.7 (PTA7/IRQ_4)
/uController/JTAG.TDO: J1.6 (SWO/TDO), U8.G13 (GPIO_AD_B0_10), U9.6 (PTA6)
/uController/JTAG.TMS: J1.2 (SWDIO/TMS), U8.E14 (GPIO_AD_B0_06), U9.5 (PTA5)
/uController/JTAG_DE_B: U8.F3 (GPIO_EMC_01), U9.15 (PTA1/IRQ_1)
/uController/JTAG_MOD: U8.F13 (GPIO_AD_B0_08), U9.13 (PTB5/IRQ_12)
/uController/MCU_DCDC_IN: C37.1, C40.1, C45.1, FB1.2, U8.K4 (DCDC_IN_Q), U8.L1 (DCDC_IN), U8.L2 (DCDC_IN)
/uController/MCU_DCDC_PSWITCH: R11.2, U8.G10 (GPIO_AD_B0_11), U8.K3 (DCDC_PSWITCH), U9.3 (PTA3)
/uController/MCU_NVCC_PLL: C43.1, C47.1, U8.P10 (NVCC_PLL)
/uController/MCU_ONOFF: U8.M6 (ONOFF)
/uController/MCU_PMIC_ON_REQ: U8.K7 (PMIC_ON_REQ)
/uController/MCU_PMIC_STBT_REQ: U8.L7 (PMIC_STBY_REQ)
/uController/MCU_POR_B: J1.10 (~RESET), U8.M7 (POR_B), U9.9 (PTB1/IRQ_6)
/uController/MCU_VDD_HIGH_CAP: C31.1, C34.1, U8.P8 (VDD_HIGH_CAP)
/uController/MCU_VDD_SNVS_CAP: C41.1, U8.M10 (SNVS_CAP)
/uController/MCU_VDD_USB_VCAP: C27.1, C28.1, U8.K8 (VDD_USB_CAP)
/uController/MCU_WAKEUP: U8.L6 (WAKEUP)
/uController/PSRAM.CLK: U2.6 (CLK), U8.D2 (GPIO_EMC_25)
/uController/PSRAM.DATA0: U2.5 (DI/IO0), U8.B3 (GPIO_EMC_26)
/uController/PSRAM.DATA1: U2.2 (DO/IO1), U8.A2 (GPIO_EMC_27)
/uController/PSRAM.DATA2: U2.3 (~WP/IO2), U8.D1 (GPIO_EMC_28)
/uController/PSRAM.DATA3: U2.7 (~HLD/~RST/IO3), U8.E1 (GPIO_EMC_29)
/uController/PSRAM.~CS1: U2.1 (~CS), U8.F1 (GPIO_EMC_22)
/uController/PSRAM.~CS: U8.D3 (GPIO_EMC_24)
/uController/SD.CLK: U8.J3 (GPIO_SD_B0_01)
/uController/SD.CMD: U8.J4 (GPIO_SD_B0_00)
/uController/SD.DATA0: U8.J1 (GPIO_SD_B0_02)
/uController/SD.DATA1: U8.K1 (GPIO_SD_B0_03)
/uController/SD.DATA2: U8.H2 (GPIO_SD_B0_04)
/uController/SD.DATA3: U8.J2 (GPIO_SD_B0_05)
/uController/SOC_DCDD_LP: L1.1, U8.M1 (DCDC_LP), U8.M2 (DCDC_LP)
/uController/SOC_RTC_XTALI: C30.1, U8.N9 (RTC_XTALI), Y2.1
/uController/SOC_RTC_XTALO: C33.1, U8.P9 (RTC_XTALO), Y2.2
/uController/SOC_VDD_CORE: C35.1, C38.1, C42.1, C46.1, C49.1, C50.1, L1.2, U8.F6 (VDD_SOC_IN), U8.F7 (VDD_SOC_IN), U8.F8 (VDD_SOC_IN), U8.F9 (VDD_SOC_IN), U8.G6 (VDD_SOC_IN), U8.G9 (VDD_SOC_IN), U8.H6 (VDD_SOC_IN), U8.H9 (VDD_SOC_IN), U8.J5 (DCDC_SENSE), U8.J9 (VDD_SOC_IN)
/uController/SOC_XTALI: C29.1, R12.2, U8.P11 (XTALI), Y1.1
/uController/SOC_XTALO: C32.1, U8.N11 (XTALO), Y1.3
/uController/USB1.DN: J2.A7 (D-), J2.B7 (D-), U8.M8 (USB_OTG1_DN); also elsewhere on the board
/uController/USB1.DP: J2.A6 (D+), J2.B6 (D+), U8.L8 (USB_OTG1_DP); also elsewhere on the board
/uController/USB1.VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U8.N6 (USB_OTG1_VBUS); also elsewhere on the board
GND: C6.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R11.1, R12.1, U2.4 (GND), U8.A1 (VSS), U8.A14 (VSS), U8.B5 (VSS), U8.B10 (VSS), U8.E2 (VSS), U8.E13 (VSS), U8.G7 (VSS), U8.G8 (VSS), U8.H7 (VSS), U8.H8 (VSS), U8.J7 (VSS), U8.J8 (VSS), U8.K2 (VSS), U8.K6 (TEST_MODE), U8.K9 (NGND_KEL0), U8.K13 (VSS), U8.L9 (VSS), U8.N1 (DCDC_GND), U8.N2 (DCDC_GND), U8.N5 (VSS), U8.N8 (VSS), U8.P1 (VSS), U8.P14 (VSS), U9.2 (VSS), U9.17 (EPAD), U10.4 (GND), U10.9 (EP), Y1.2, Y1.4; also elsewhere on the board
unnamed: TP13.1, U9.14 (PTA0/IRQ_0)
unnamed: TP14.1, U9.16 (PTA2)

Notes on the sheet:
ADDITIONAL PSRAM, FLASH (OPTION)
JTAG HEADER
MCU GPIO
EXTERNAL BOOTLOADER
EXTERNAL FLASH
OTG USB CONNECTOR
MCU POWER & CTRL

Parts:
Q1, Q2, Q3, Q4: PMZB290UNE2YL; SOT-883; MPN PMZB290UNE2YL
R4, R16, R18, R20: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP
R15, R17, R19, R21: R_0R62_0603; 0603-res; MPN CRL0603-FW-R620ELF

Connections:
GND: Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R4.1, R16.1, R18.1, R20.1; also elsewhere on the board
unnamed: Q1.1 (G), R4.2
unnamed: Q1.3 (D), R15.1
unnamed: Q2.1 (G), R16.2
unnamed: Q2.3 (D), R17.1
unnamed: Q3.1 (G), R18.2
unnamed: Q3.3 (D), R19.1
unnamed: Q4.1 (G), R20.2
unnamed: Q4.3 (D), R21.1

Parts:
C7: C_100n_0402; 0402-cap; MPN GRM155R61H104KE14D
C8: C_10u_16V_0603; 0603-cap; MPN GRM188C81C106MA73D
U3: DRV8835DSSR; WSON-12_2x3mm; MPN DRV8835DSSR

Connections:
/Motors Drivers/DRV8835_DIR_A: U3.10 (DIR_A)
/Motors Drivers/DRV8835_DIR_B: U3.8 (DIR_B)
/Motors Drivers/DRV8835_EN: U3.11 (EN)
/Motors Drivers/DRV8835_PWM_A: U3.9 (PWM_A)
/Motors Drivers/DRV8835_PWM_B: U3.7 (PWM_B)
GND: C7.2, C8.2, U3.6 (GND), U3.13 (GND); also elsewhere on the board
unnamed: C7.1, U3.12 (VCC)
unnamed: C8.1, U3.1 (VM)

Parts:
BZ1: CMT-5023S-SMT-TR; CMT5023SSMTTR; MPN CMT-5023S-SMT-TR
C23: C_10u_0402; 0402-cap; MPN CC0402MRX5R5BB106
D1: 1N4148WS; SOD-323F; MPN 1N4148WS
D2: LTST-C19HE1WT; LED_Dual0603; MPN LTST-C19HE1WT
Q5: PMZB290UNE2YL; SOT-883; MPN PMZB290UNE2YL
R5: 4x2k2_0201_array; EXB18V; MPN EXB-18V222JX
R22: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP

Connections:
+3V3: BZ1.1, C23.1, D1.K, D2.4; also elsewhere on the board
/LED & Oled & Buzzer/BUZZER: Q5.1 (G), R22.2
/LED & Oled & Buzzer/~LED_1: R5.1
/LED & Oled & Buzzer/~LED_2: R5.2
/LED & Oled & Buzzer/~LED_3: R5.3
GND: C23.2, Q5.2 (S), R22.1; also elsewhere on the board
unnamed: BZ1.2, D1.A, Q5.3 (D)
unnamed: D2.1 (R), R5.6
unnamed: D2.2 (G), R5.7
unnamed: D2.3 (B), R5.8

Parts:
R1: 4x10k_0201_array; EXB18V; MPN EXB-18V103JX
R14: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP
S1: SKRHABE010; MPN SKRHABE010

Connections:
/Buttons/JOY.~DOWN: R1.6
/Buttons/JOY.~LEFT: R14.2
/Buttons/JOY.~OK: R1.8
/Buttons/JOY.~RIGHT: R1.5
/Buttons/JOY.~UP: R1.7
/Buttons/JOY_~DOWN: R1.3, S1.6 (D)
/Buttons/JOY_~LEFT: R14.1, S1.3 (C)
/Buttons/JOY_~OK: R1.1, S1.2 (CNTR)
/Buttons/JOY_~RIGHT: R1.4, S1.4 (B)
/Buttons/JOY_~UP: R1.2, S1.1 (A)
GND: S1.5 (COMM); also elsewhere on the board

Parts:
J7, J8: encoder-pads; 01x04_1.0x0.5mm_SMD; MPN AS5045B-board

Connections:
+3V3: J7.1 (VCC), J8.1 (VCC); also elsewhere on the board
/Encoders/ENC_L.A: J8.3 (A)
/Encoders/ENC_L.B: J8.4 (B)
/Encoders/ENC_R.A: J7.3 (A)
/Encoders/ENC_R.B: J7.4 (B)
GND: J7.2 (GND), J8.2 (GND); also elsewhere on the board

Schematic: imu.kicad_sch

Parts:
C1, C2, C3: C_100n_0402; 0402-cap; MPN GRM155R61H104KE14D
C4, C5: C_18p_0402; 0402-cap; MPN MC0402N180J500CT
R2: 4x10k_0201_array; EXB18V; MPN EXB-18V103JX
R3: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP
U1: BNO055; LGA-28_5.2x3.8mm_BNO0055; MPN BNO055
Y3: ECS-_327-12_5-34B-TR; SMD-2_3.2x1.5mm; MPN ECS-.327-12.5-34B-TR

Connections:
+3V3: C1.1, C2.1, R2.5, R2.8, U1.3 (VDD), U1.28 (VDDIO); also elsewhere on the board
/IMU/IMU.INT: U1.14 (INT)
/IMU/IMU.SCL: U1.19 (SCL)
/IMU/IMU.SDA: U1.20 (SDA)
/IMU/IMU_I2C_A0: R3.1, U1.17 (I2C_A0)
/IMU/IMU_PS0: R2.2, U1.6 (PS0)
/IMU/IMU_PS1: R2.3, U1.5 (PS1)
/IMU/IMU_RESET: R2.1, U1.11 (nRESET)
/IMU/IMU_XTALI: C4.1, U1.27 (XIN32), Y3.2
/IMU/IMU_XTALO: C5.1, U1.26 (XOUT32), Y3.1
/IMU/IMU_nBOOT_LOAD: R2.4, U1.4 (nBOOT_LOAD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, R2.6, R2.7, R3.2, U1.2 (GND), U1.10 (PIN10), U1.15 (PIN15), U1.16 (PIN16), U1.18 (COM2), U1.25 (GNDIO); also elsewhere on the board
unnamed: C3.1, U1.9 (CAP)

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
Board: 4 copper layers, 111 parts (27 on the bottom side), 82 nets, no tracks yet.

Other parts of the board:
J2#2: USB4105-GF-A; GCT_USB4105-GF-A
J3#2: B2B-PH-K-S_LF__SN_; PinHeader_1x2_P2mm_Drill1mm

Their connections:
/uController/USB1.DN: J2#2.A7 (D-), J2#2.B7 (D-); also elsewhere on the board
/uController/USB1.DP: J2#2.A6 (D+), J2#2.B6 (D+); also elsewhere on the board
/uController/USB1.VBUS: J2#2.A4 (VBUS), J2#2.A9 (VBUS), J2#2.B4 (VBUS), J2#2.B9 (VBUS); also elsewhere on the board
GND: J2#2.A1 (GND), J2#2.A12 (GND), J2#2.B1 (GND), J2#2.B12 (GND), J2#2.S1 (SHIELD); also elsewhere on the board
unnamed 102: J3#2.2; also elsewhere on the board

## KiCad design double_bldc_controll_hat/double_bldc_controll_hat.kicad_pcb

Board: 2 copper layers, 65.0 x 56.0 mm, 5 parts (1 on the bottom side), 3 nets, no tracks yet.

Parts:
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical

Connections:
+3V3: P1.1, P1.17
+5V: P1.2, P1.4
GND: P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39

## KiCad design vl53l0_board/vl53l0_board.kicad_pcb

Board: 4 copper layers, 5.0 x 3.0 mm, 3 parts (2 on the bottom side), 6 nets.

Parts:
J17: Conn_01x05; 01x05_1.0x0.5mm_SMD
R13: 47K; R_0402_1005Metric
U7: VL53L0X; SENSOR_VL53L0X

Connections:
+2V8: J17.5, R13.1, U7.1, U7.11
/Distance Sensors/LOCAL_SCL: J17.4, U7.10
/Distance Sensors/LOCAL_SDA: J17.3, U7.9
/Distance Sensors/XSHUT_[3]: J17.1, U7.5
GND: J17.2, U7.2, U7.3, U7.4, U7.6, U7.12
unnamed: R13.2, U7.7

## KiCad design as5045b_board/as5045b_board.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0402_1005Metric
C3, C9: 4.7uF; C_0603_1608Metric
C5, C7: 2.2uF; C_0603_1608Metric
C6, C8: 1uF; C_0402_1005Metric
J1, J2: Conn_01x04; 01x04_1.0x0.5mm_SMD
R1, R3, R5, R7: 2K2; R_0402_1005Metric
R2, R4, R6, R8: 3K3; R_0402_1005Metric
U1, U2: AS5304; TSSOP-20_4.4x6.5mm_P0.65mm
U3, U4: LTC3221; DFN-6-1EP_2x2mm_P0.5mm_EP0.61x1.42mm

Connections:
+5V: C1.1, C2.1, C3.1, C9.1, U1.3 (VDDP), U1.7 (VDD), U1.16 (VDDA), U2.3 (VDDP), U2.7 (VDD), U2.16 (VDDA), U3.6 (VOUT), U4.6 (VOUT)
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C9.2, J1.2, J2.2, R2.2, R4.2, R6.2, R8.2, U1.1 (VSS), U1.15 (T_GND), U1.20 (~CS), U2.1 (VSS), U2.15 (T_GND), U2.20 (~CS), U3.4 (GND), U3.7 (GND), U4.4 (GND), U4.7 (GND)
unnamed: C5.1, J1.1, U3.3 (~SHDN), U3.5 (VIN)
unnamed: C6.1, U3.1 (C+)
unnamed: C6.2, U3.2 (C-)
unnamed: C7.1, J2.1, U4.3 (~SHDN), U4.5 (VIN)
unnamed: C8.1, U4.1 (C+)
unnamed: C8.2, U4.2 (C-)
unnamed: J1.3, R1.2, R2.1
unnamed: J1.4, R5.2, R6.1
unnamed: J2.3, R7.2, R8.1
unnamed: J2.4, R3.2, R4.1
unnamed: R1.1, U1.2 (A)
unnamed: R3.1, U2.2 (A)
unnamed: R5.1, U1.4 (B)
unnamed: R7.1, U2.4 (B)

Notes on the sheet:
Note: Pin 20 of AS5304 is connected manually to GND on PBC Layout Editor

Board: 4 copper layers, 22.0 x 12.0 mm, 26 parts (0 on the bottom side), 16 nets.

Other parts of the board:
mouse-bite-2mm-slot, mouse-bite-2mm-slot#2, mouse-bite-2mm-slot#3, mouse-bite-2mm-slot#4: VAL**; mouse-bite-2mm-slot

## KiCad design debug_station/debug_station.kicad_pcb

Parts:
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: STM14_SW; PinHeader_2x07_P1.27mm_Vertical_SMD

Connections:
+3V3: TP5.1, U1.3 (VCC)
/CC1: J1.A5 (CC1), TP8.1
/CC2: J1.B5 (CC2), TP9.1
/D+: J1.A6 (D+), J1.B6 (D+), TP11.1
/D-: J1.A7 (D-), J1.B7 (D-), TP12.1
/SWDCLK: TP1.1, U1.6 (SWDCLK/TCK)
/SWDIO: TP2.1, U1.4 (SWDIO/TMS)
/SWDO: TP3.1, U1.8 (SWO/TDO)
/VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP7.1
/~RESET: TP10.1, U1.12 (~RESET~)
GND: J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), TP4.1, TP6.1, U1.5 (GND), U1.11 (GNDDetect)

Notices in the files:
parts and their libraries:
License: MIT
